# Keil uVision project TsinghuaDoor.uvprojx, settings and files
target TsinghuaDoor (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TsinghuaDoor +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\ws2812;..\HARDWARE\OLED;..\HARDWARE\KEY;..\GAME;..\OLED_GUI;..\HARDWARE\BEEP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ws2812/: WS2812B.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c
  group README
    ../: README.TXT
  group GAME
    ../GAME/: GameMap.c GameMove.c Game_flow.c Game_turtle.c
  group OLEDGUI
    ../OLED_GUI/: FHZ17.c FHZ20.c FHZ24.c FHZ30.c FHZ37B.c FHZ40B.c FHZ48.c font.c gui.c gui_2d_lib.c gui_interface.c gui_text_lib.c gui_widget_image.c gui_widget_progbar.c gui_widget_text.c
